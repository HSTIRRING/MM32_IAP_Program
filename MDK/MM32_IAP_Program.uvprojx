# Keil uVision project MM32_IAP_Program.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L362PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32_IAP_Program
  BeforeMake: fromelf --bin !L --output MM32_IAP_Program.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MM32L3xx\HAL_lib\inc;..\MM32L3xx\Include;..\Drivers;..\Application;..\CMSIS\KEIL_CORE;..\cortexM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c program_protocol.c soft_timer.c hardware.c program.c
  group Drivers
    ../Drivers/: board.c device_usart.c device_led.c
  group MM32L3xx
    ../MM32L3xx/HAL_lib/src/: HAL_wwdg.c HAL_uart.c HAL_rcc.c HAL_pwr.c HAL_misc.c HAL_iwdg.c HAL_gpio.c HAL_flash.c HAL_exti.c HAL_dma.c HAL_crc.c
    ../MM32L3xx/Source/: system_MM32L3xx.c
    ../MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group cortexM3
    ../cortexM3/: context.s
  group Doc
    ../: MM32_IAP_IAR_protocol.txt
